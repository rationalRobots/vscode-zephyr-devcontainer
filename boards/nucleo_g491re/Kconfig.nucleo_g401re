## boards/nucleo_g491re/Kconfig.nucleo_g401re
```kconfig
# Copyright (c) 2016 Matthias Boesl
# SPDX-License-Identifier: Apache-2.0

config BOARD_NUCLEO_G491RE
	select SOC_STM32G491RE
```
